## src/examples/custom/Kconfig
```kconfig
menuconfig EXAMPLES_CUSTOM
	bool "custom"
	default y
	---help---
		Enable support for custom
```
